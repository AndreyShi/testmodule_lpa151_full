# Keil uVision project testmodule_lpa_151.uvprojx, settings and files
target testmodule_lpa_151 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746BGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: testmodule_lpa_151 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_USB_FS,USE_USB_HS
  c include: ../Core;../Inc;../Platform;../../lib_serialize;../../testhead_v2;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/BSP/Components/n25q128a;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/STM32F7xx_HAL_Driver/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Host_Library/Core/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include;C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\testmodule_lpa_151.sct
  link misc: --diag_suppress=L6329
  group Application/Engine
    ../Core/: aux_functions.cpp control_functions.cpp engine_functions.cpp read_functions.cpp lpa_functions.cpp special_testing_functions.cpp specific_functions.cpp engine_151_states.cpp KControlLpaState.cpp KEraseLpaState.cpp KUpdateLpaState.cpp KModuleState151.cpp
  group Application/Lib_serialize
    ../../lib_serialize/: KAbstractEngine.cpp KModuleEngine.cpp KModuleCommand.cpp KAbstractBusManager.cpp KBusFrameHeader.cpp KBusFrame.cpp bus_frames.cpp KModuleState.cpp KBusAddress.cpp KParameter.cpp KVersion.cpp aux_commands.cpp control_commands.cpp engine_commands.cpp engine_states_if.cpp frame_headers.cpp KNullEngine.cpp lpa_commands.cpp read_commands.cpp specific_commands.cpp
  group Application/Managers
    ../Core/: KBusManager.cpp frame_functions.cpp KUSBManager.cpp
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/Platform
    ../Platform/: boot.c bus_uart_if.c emu_u.c firmware.c gpio_if.c isp_if.c isp_if_nb.c qspi_flash.c relay_if.c render.c ssd1306.c version.cpp
  group Application/User
    ../Src/: animation.c hid_lpa.c main.cpp menu.c retarget.c usbh_hid_lpa.c
  group Drivers/CMSIS
    C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/CubeMX
    ../Src/: dma.c gpio.c quadspi.c spi.c stm32f7xx_hal_msp.c stm32f7xx_it.c tim.c usart.c usb_device.c usb_host.c usbd_cdc_if.c usbd_conf.c usbd_desc.c usbh_conf.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_usb.c
  group Middlewares/USB_Device_Library
    C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_Host_Library
    C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    C:/Users/kupriyanov/STM32Cube/Repository/STM32Cube_FW_F7_V1.12.0/Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_parser.c
